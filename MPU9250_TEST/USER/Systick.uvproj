# Keil uVision project Systick.uvproj, settings and files
target Systick (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: jiao_stm32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER;..\CMSIS;..\LIB\inc;..\LIB\src;.\eMPL
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c Systick.c led.c Imu_Init_Position.c inv_imu_app.c mpu9250_driver.c delay.c stm32_iic.c usart.c Time.c
    ./eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group STARTUPCODE
    ../CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
